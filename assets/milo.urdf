Commit message: update

File: assets/milo.urdf (robot description, URDF)
Before this commit: robot Milo-01, 29 links, 28 joints
Links:
- link neck: geometry collision box size=0.065 0.065 0.14; visual box size=0.065 0.065 0.14
